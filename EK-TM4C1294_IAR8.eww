<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TivaWare_C_Series-2.1.4.178\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TivaWare_C_Series-2.1.4.178\grlib\grlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\lab1\lab1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\lab2\lab2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\lab3\lab3.ewp</path>
    </project>
    <batchBuild />
</workspace>
